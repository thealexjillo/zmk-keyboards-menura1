## boards/shields/menura/Kconfig.defconfig
```kconfig
if SHIELD_MENURA_LEFT || SHIELD_MENURA_RIGHT

config ZMK_SPLIT
    default y

config ZMK_SLEEP
    default n

endif
```
